# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=3
  c define: RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, LFS_CONFIG=lfs_config.h, __STDC_LIMIT_MACROS, USE_HAL_DRIVER, __RTTHREAD__, RT_USING_ARMLIBC, STM32F407xx
  c include: ..\..\..\include;..\..\..\components\net\utest;..\..\..\components\utilities\resource;board\ports\w25q128;..\..\..\components\net\netdev\include;..\..\..\components\finsh;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\libc\posix\io\epoll;..\..\..\components\net\sal\impl;..\..\..\components\dfs\dfs_v1\filesystems\devfs;packages\at_device-latest\inc;..\..\..\components\net\sal\include\socket\sys_socket;packages\pahomqtt-latest\MQTTPacket\src;..\..\..\components\net\at\include;..\..\..\components\drivers\include;applications;packages\littlefs-latest;..\..\..\components\net\sal\include;packages\pahomqtt-latest\MQTTClient-RT;..\..\..\components\libc\posix\ipc;packages\cJSON-v1.7.17;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\drivers\include;..\..\..\libcpu\arm\cortex-m4;packages\at_device-latest\class\esp8266;..\..\..\components\net\at\at_socket;..\..\..\components\libc\posix\io\eventfd;board\CubeMX_Config\Core\Inc;board\ports\led;..\..\..\components\net\sal\include\dfs_net;..\..\..\components\drivers\smp_call;..\..\..\components\fal\inc;board\ports\esp8266-01s;..\..\..\components\dfs\dfs_v1\include;..\..\..\components\drivers\include;board\ports\onenet;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\poll;packages\stm32f4_hal_driver-latest\Inc\Legacy;packages\stm32f4_hal_driver-latest\Inc;..\..\..\components\drivers\include;board;..\..\..\components\net\sal\include\socket;..\..\..\components\drivers\include;board\ports\onenet\rtthread-package-onenet\ports;board\ports\onenet\rtthread-package-onenet\inc;packages\CMSIS-Core-latest\Include;..\..\..\components\drivers\phy;.;..\libraries\HAL_Drivers\drivers\config;packages\stm32f4_cmsis_driver-latest\Include;..\..\..\libcpu\arm\common;..\libraries\HAL_Drivers\drivers\drv_flash;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\drivers;..\..\..\components\libc\compilers\common\include;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension;..\..\..\components\drivers\spi\sfud\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group AT
    ../../../components/net/at/src/: at_utils.c at_cli.c at_client.c
    ../../../components/net/at/at_socket/: at_socket.c
  group at_device
    packages/at_device-latest/src/: at_device.c
    packages/at_device-latest/class/esp8266/: at_device_esp8266.c at_socket_esp8266.c
    packages/at_device-latest/samples/: at_sample_esp8266.c
  group cJSON
    packages/cJSON-v1.7.17/: cJSON.c cJSON_Utils.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/mtd/: mtd_nor.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
    ../../../components/drivers/spi/: dev_spi.c dev_spi_core.c dev_spi_flash_sfud.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_dma.c drv_gpio.c drv_spi.c drv_usart.c
    ../libraries/HAL_Drivers/drivers/drv_flash/: drv_flash_f4.c
    ../libraries/HAL_Drivers/: drv_common.c
    board/CubeMX_Config/Core/Src/: stm32f4xx_hal_msp.c
    board/: board.c
  group Esp8266
    board/ports/esp8266-01s/: drv_esp8266.c
  group Fal
    ../../../components/fal/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    ../../../components/fal/samples/porting/: fal_flash_sfud_port.c
  group Filesystem
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Led
    board/ports/led/: drv_led.c
  group Libc
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../components/libc/posix/io/poll/: poll.c select.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group littlefs
    packages/littlefs-latest/: dfs_lfs.c lfs.c lfs_crc.c lfs_util.c
  group onenet
    board/ports/onenet/rtthread-package-onenet/src/: onenet_mqtt.c onenet_reply.c
    board/ports/onenet/rtthread-package-onenet/ports/: onenet_port.c
    board/ports/onenet/rtthread-package-onenet/samples/: onenet_sample.c
  group paho-mqtt
    packages/pahomqtt-latest/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    packages/pahomqtt-latest/MQTTClient-RT/: paho_mqtt_pipe.c
  group SAL
    ../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../../components/net/sal/dfs_net/: dfs_net.c
    ../../../components/net/sal/impl/: af_inet_at.c
    ../../../components/net/sal/socket/: net_netdb.c net_sockets.c
    ../../../components/net/sal/src/: sal_socket.c
  group STM32F4-CMSIS
    packages/stm32f4_cmsis_driver-latest/Source/Templates/: system_stm32f4xx.c
    packages/stm32f4_cmsis_driver-latest/Source/Templates/arm/: startup_stm32f407xx.s
  group STM32F4-HAL
    packages/stm32f4_hal_driver-latest/Src/: stm32f4xx_hal.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_spi.c stm32f4xx_hal_qspi.c stm32f4xx_hal_nor.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c
  group Utilities
    ../../../components/utilities/resource/: resource_id.c
  group W25Q128
    board/ports/w25q128/: drv_w25q128.c
